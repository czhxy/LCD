# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: --gnu
  c include: ..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\third_lib\FreeRTOS\inc;..\driver;..\app;..\bsp;..\font;..\mod;..\app\image;..\task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s
  group system
    ../firmware/cmsis/device/: system_stm32f4xx.c
  group app
    ../app/: main.c main.h
    ../firmware/cmsis/device/: stm32f4xx_it.c
  group app/image
    ../app/image/: image.h img_meihua.c img_dashboard.c
  group driver
    ../driver/: Delay.c Delay.h
    ../bsp/: bsp_key.c bsp_key.h bsp_led.c bsp_led.h bsp_usart.c bsp_usart.h bsp_lcd.c bsp_lcd.h
  group mod
    ../mod/: mod_lcd.c mod_lcd.h mod_log.c mod_log.h
  group task
    ../task/: task_uart.c task_ui.c
  group third_lib/FreeRTOS
    ../third_lib/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c heap_4.c port.c
    ../third_lib/FreeRTOS/inc/: FreeRTOSConfig.h
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group font
    ../font/: font.h font16_maple.c font24_maple_bold.c font32_maple_bold.c
